
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_beaglebone = "file://am335x-bone-gps-clock.dts"
SRC_URI_raspberrypi0 = "file://bcm2835-rpi-zero-gps-clock.dts"

